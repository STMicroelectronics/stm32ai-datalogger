# IAR project USB_WCID_ImageDisplay.ewp, settings and files
configuration USB_WCID_ImageDisplay_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M4 ST STM32H747XI_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H747xx
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../Drivers/CMSIS/Include; ..\..\..\..\..\Drivers\Components\is42s32800j; ..\..\..\..\..\Drivers\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_WCID_ImageDisplay_CM4.hex
  ILINK.IlinkOutputFile: USB_WCID_ImageDisplay_CM4.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USB_WCID_ImageDisplay_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx
  ICCARM.CCIncludePath2: ../CM7/USB_DEVICE/App; ../CM7/USB_DEVICE/Target; ../CM7/Core/Inc; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../../../../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../../../../Drivers/CMSIS/Include; ..\..\..\..\..\Drivers\STM32H747I-DISCO; ..\..\..\..\..\Drivers\Components\Common; ..\..\..\..\..\Drivers\Components\is42s32800j; ..\Utilities\lcd; ..\Utilities\Fonts
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: USB_WCID_ImageDisplay_CM7.hex
  ILINK.IlinkOutputFile: USB_WCID_ImageDisplay_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: ai_logging.c main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7/USB_DEVICE/App
    ../CM7/Core/Src/: usbd_wcid_interface.c usbd_wcid_streaming.c
  group Application/User/CM7/USB_DEVICE/Target
    ../CM7/Core/Src/: usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
  group Drivers/BSP/Components/is42s32800j
    ../../../../../Drivers/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/Components/otm8009a
    ../../../../../Drivers/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group Drivers/BSP/STM32H747I-DISCO
    ../../../../../Drivers/STM32H747I-DISCO/: stm32h747i_discovery.c stm32h747i_discovery_bus.c stm32h747i_discovery_lcd.c stm32h747i_discovery_sdram.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Utilities/lcd
    ../Utilities/lcd/: stm32_lcd.c stm32_lcd.h
