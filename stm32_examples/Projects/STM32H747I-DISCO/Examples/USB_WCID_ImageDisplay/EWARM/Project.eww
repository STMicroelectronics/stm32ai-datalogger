<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB_WCID_ImageDisplay.ewp</path>
  </project>
  <batchBuild />
</workspace>
