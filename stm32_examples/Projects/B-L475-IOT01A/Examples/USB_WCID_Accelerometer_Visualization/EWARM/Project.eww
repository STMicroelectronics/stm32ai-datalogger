<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB_WCID_Accelerometer_Visualization.ewp</path>
  </project>
  <batchBuild />
</workspace>
