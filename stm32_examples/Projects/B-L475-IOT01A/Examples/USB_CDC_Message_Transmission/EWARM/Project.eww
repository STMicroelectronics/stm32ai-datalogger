<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB_CDC_Message_Transmission.ewp</path>
  </project>
  <batchBuild />
</workspace>
